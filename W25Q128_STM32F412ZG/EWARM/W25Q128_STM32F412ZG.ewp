# IAR project W25Q128_STM32F412ZG.ewp, settings and files
configuration W25Q128_STM32F412ZG (ARM, debug)
  General.OGChipSelectEditMenu: STM32F412ZG ST STM32F412ZG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F412Zx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: W25Q128_STM32F412ZG.hex
  postbuild: cmd.exe /C copy ".\W25Q128_STM32F412ZG\Exe\$TARGET_BNAME$.out" "..\$TARGET_BNAME$.stldr"
  ILINK.IlinkOutputFile: W25Q128_STM32F412ZG.out
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkExtraOptions: --no_remove
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/User/Core
    ../Core/Src/: debug.c Dev_Inf.c Loader_Src.c main.c stm32f4xx_hal_msp.c system_stm32f4xx.c w25q128jv_ll.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_qspi.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
