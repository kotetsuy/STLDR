# IAR project W25Q128_STM32F412ZG.ewp, settings and files
configuration W25Q128_STM32F412ZG (ARM, debug)
  General.OGChipSelectEditMenu: STM32F412ZG ST STM32F412ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F412Zx
  ICCARM.CCIncludePath2: Core\Inc; Drivers\CMSIS\Device\ST\STM32F4xx\Include; Drivers\CMSIS\Include; Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; Drivers\STM32F4xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: W25Q128_STM32F412ZG.hex
  ILINK.IlinkOutputFile: W25Q128_STM32F412ZG.out
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkExtraOptions: --diag_suppress Lp005,Lp006
  ILINK.IlinkProgramEntryLabel: Init
  group Core/Src
    Core/Src/: Dev_Inf.c Loader_Src.c stm32f4xx_hal_msp.c system_stm32f4xx.c w25q128jv.c
  group Drivers/STM32F4xx_HAL_Driver/Src
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c
