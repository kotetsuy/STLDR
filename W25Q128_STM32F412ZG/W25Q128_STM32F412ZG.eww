<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\W25Q128_STM32F412ZG.ewp</path>
  </project>
  <batchBuild/>
</workspace>


